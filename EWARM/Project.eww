<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Proj4_ZEPA.ewp</path>
  </project>
  <batchBuild />
</workspace>
